<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F103_USART_2_DOUT.ewp</path>
  </project>
  <batchBuild />
</workspace>
